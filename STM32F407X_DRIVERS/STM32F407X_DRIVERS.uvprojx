# Keil uVision project STM32F407X_DRIVERS.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407X_DRIVERS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ./: main.c led.c led.h i2c_main.c i2c_main.h
  group HAL_Src
    ./: gpio.c spi.c i2c.c uart.c
  group HAL_Inc
    ./: gpio.h spi.h i2c.h uart.h
software components: CMSIS:CORE 5.2.0, Device:Startup 2.6.2
